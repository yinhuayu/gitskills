# Keil uVision project f303.uvprojx, settings and files
target Target 1 (6160000::V6.16::ARMCLANG)
  device: GD32F303RC GigaDevice
  pack: GigaDevice.GD32F30x_DFP.2.1.0
  cpu: IRAM(0x20000000,0x0C000) IROM(0x08000000,0x040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: f303 +hex
  AfterMake: fromelf.exe  --bin -o "$L@L.bin" "#L"
  c flags: Optim=1 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=1
  c define: GD32F30X_HD,__FPU_PRESENT,__FPU_USED
  c include: ..\CMSIS;..\inc;..\segger_rtt;..\src;..\fw_lib\inc
  library: MicroLIB
  memory RVCT4: ROM 0x800e000 size 0x19000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group src
    ../src/: fitness.c bsp_adc.c enc.c foc.c gd32f30x_it.c main.c mc_math.c pid.c pwm6.c soft_schd.c systick.c encoder.c FYLsin.c ntc_lut_mos.c ntc_lut_motor.c PROTECT.c CAN.c FMC.c Hardware_Init.c Protocol_FrameHandler.c UART.c Interrupt.c IAP.c
  group rtt
    ../segger_rtt/: log_hex.c SEGGER_RTT.c SEGGER_RTT_printf.c
software components: CMSIS:CORE 5.5.0, Device:GD32F30x_StdPeripherals:ADC 2.1.0, Device:GD32F30x_StdPeripherals:BKP 2.1.0, Device:GD32F30x_StdPeripherals:CAN 2.1.0, Device:GD32F30x_StdPeripherals:CRC 2.1.0, Device:GD32F30x_StdPeripherals:CTC 2.1.0, Device:GD32F30x_StdPeripherals:DAC 2.1.0, Device:GD32F30x_StdPeripherals:DBG 2.1.0, Device:GD32F30x_StdPeripherals:DMA 2.1.0, Device:GD32F30x_StdPeripherals:ENET 2.1.0, Device:GD32F30x_StdPeripherals:EXMC 2.1.0, Device:GD32F30x_StdPeripherals:EXTI 2.1.0, Device:GD32F30x_StdPeripherals:FMC 2.1.0, Device:GD32F30x_StdPeripherals:FWDGT 2.1.0, Device:GD32F30x_StdPeripherals:GPIO 2.1.0, Device:GD32F30x_StdPeripherals:I2C 2.1.0, Device:GD32F30x_StdPeripherals:MISC 2.1.0, Device:GD32F30x_StdPeripherals:PMU 2.1.0, Device:GD32F30x_StdPeripherals:RCU 2.1.0, Device:GD32F30x_StdPeripherals:RTC 2.1.0, Device:GD32F30x_StdPeripherals:SDIO 2.1.0, Device:GD32F30x_StdPeripherals:SPI_I2S 2.1.0, Device:GD32F30x_StdPeripherals:TIMER 2.1.0, Device:GD32F30x_StdPeripherals:USART 2.1.0, Device:GD32F30x_StdPeripherals:WWDGT 2.1.0, Device:GD32F30x_libopt 2.1.0, Device:Startup 2.1.0
